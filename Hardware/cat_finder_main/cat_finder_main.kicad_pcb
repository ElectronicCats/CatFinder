# Repository ElectronicCats/CatFinder

File README.md:

# CatFinder

The Electronic Cats along with The Inventor's House have developed a new development kit for a Mars Rover in which almost everyone can participate

"The CatFinder" is an exploration vehicle that collects data from the environment in which it travels.

The CatFinder Rover is cappable of transmit:

- Humidity
- Atmosphere pressure
- Temperature 
- CO2 levels in ppm
- TVOC levels in ppb 
- Position with acelerometer and gyroscope
- Video broadcasting.

Yes! we're capable of getting data, control the motors and transmitting video, through WiFi thanks to the ESP32-CAM and the [Bast Pro Mini](https://github.com/ElectronicCats/Bast-Pro-Mini-M0) (Which is a devBoard fully compatible with the Arduino Pro Mini).

## Licence ##

Firmware released under an GNU AGPL v3.0 license. See the LICENSE file for more information.

Hardware released under an CERN Open Hardware Licence v1.2. See the LICENSE_HARDWARE file for more information.

Electronic Cats is a registered trademark, please do not use if you sell these PCBs.

Electronic Cats invests time and resources providing this open source design, please support Electronic Cats and open-source hardware by purchasing products from Electronic Cats!

## KiCad design Hardware/cat_finder_main/cat_finder_main.kicad_pcb

Parts:
C1, C2: 10uf; CP_Radial_D5.0mm_P2.00mm
C3: 0.1uf; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: SB260-E3/54; D_A-405_P7.62mm_Horizontal
D2: ON; LED_D5.0mm
J1: BATT; TerminalBlock_bornier-2_P5.08mm
J2: BME280; PinHeader_1x06_P2.54mm_Vertical
J3: CSS811; PinHeader_1x08_P2.54mm_Vertical
J4: DRIVERS; PinHeader_1x06_P2.54mm_Vertical
J5: GY-87; PinHeader_1x08_P2.54mm_Vertical
J6: PROG; PinHeader_1x03_P2.54mm_Vertical
J7: FTDI; PinHeader_1x06_P2.54mm_Vertical
J8: Digital; PinHeader_1x12_P2.54mm_Vertical
J9: i2c; PinHeader_1x02_P2.54mm_Vertical
J10: Analog; PinHeader_1x12_P2.54mm_Vertical
J11: Bast Pin; PinSocket_1x05_P2.54mm_Vertical
JP1: Engine 2B; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP2: Engine 1A; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP3: Engine 2A; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP4: Engine 1B; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP7: Engine 1 A; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP8: Engine 1B; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP9: Engine 2A; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP10: Engine 2B; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1: Q_PMOS_DGS; TO-92_Inline
R1: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: ON Battery; SW_1825116-1
U1: LD1117A33; TO-220-3_Vertical
U2: MCP732831CHARGER; charger_EC_3.3V_battery
U3: ESP32-CAM

Connections:
+3V3: D2.2 (A), J2.1, J3.1, J3.6, J3.7, J4.6, J5.2, J10.9, SW1.3 (C), U3.8 (3V3)
/2: J8.5
/3: J8.6
/3.3V-5V: U3.4 (VCC)
/4: J8.7
/5: J8.8
/5V: U3.9 (5V)
/6: J8.9
/7: J8.10
/8: J8.11
/9: J8.12, JP10.1
/10: J10.1, J11.1
/11: J10.2, J11.2
/12: J10.3, J11.3
/13: J10.4, J11.4
/A0: J10.5, J11.5
/A1: J10.6, JP8.1
/A2: J10.7, JP7.1
/A3: J10.8, JP9.1
/BATT: J1.2, Q1.3 (S), U2.3 (OUT)
/CTS: J7.5
/DRDY: J5.8
/DTR: J7.1
/FSYNC: J5.6
/GPIO0: J6.2, U3.6 (IO0)
/GPIO2: U3.15 (IO2)
/GPIO4: U3.16 (IO4)
/GPIO12: J4.5, JP2.2, JP8.2
/GPIO12E: JP2.1, U3.11 (IO12)
/GPIO13: J4.4, JP4.2, JP7.2
/GPIO13E: JP4.1, U3.12 (IO13)
/GPIO14: J4.2, JP1.2, JP10.2
/GPIO14E: JP1.1, U3.14 (IO14)
/GPIO15: J4.3, JP3.2, JP9.2
/GPIO15E: JP3.1, U3.13 (IO15)
/INTA: J5.7
/RST: J8.3, J10.10
/RX: J7.3, J8.1, U3.3 (UnR)
/SCL: J2.3, J3.3, J5.4, J9.2
/SCLE: U3.7 (IO16)
/SDA: J2.4, J3.4, J5.5, J9.1
/TX: J7.2, J8.2, U3.2 (UoT)
/VCC-IN: J5.1
GND: C1.2, C2.2, C3.2, J1.1, J2.2, J3.2, J3.5, J4.1, J5.3, J6.3, J7.6, J8.4, J10.11, R1.1, R2.2, U1.1 (GND), U2.2 (GND), U2.4 (GND), U3.1 (GND), U3.5 (GND), U3.10 (GND)
unnamed: C1.1, D1.1, Q1.1 (D), U1.3 (VI)
unnamed: C2.1, SW1.2 (B), U1.2 (VO)
unnamed: D2.1 (K), R1.2
VCC: C3.1, D1.2, J10.12, Q1.2 (G), R2.1, U2.1 (VCC)

Notes on the sheet:
REGULATOR
CHARGER
SENSORS
MICROCONTROLLER
BAST PRO-MINI

Board: 2 copper layers, 85.0 x 70.0 mm, 31 parts (8 on the bottom side), 30 nets.

## KiCad design Hardware/rover_car/rover_car.kicad_pcb

Parts:
C1, C4, C7: .01uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C5, C8: 10uF; CP_Elec_4x5.4
C3, C6, C9: 2.2uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Conn_01x06_Female; PinSocket_1x06_P2.54mm_Vertical
J3: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
M1, M2, M3, M4, M5, M6: Motor_DC; TerminalBlock_bornier-2_P5.08mm
R1, R2, R6: 200mOhms; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4, R5: 200mOhm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1, U2, U3: DRV8833PWP; HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask2.46x2.31mm_The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

Connections:
+12V: C1.1, C2.1, C4.1, C5.1, C7.1, C8.1, J3.1, U1.12 (VM), U2.12 (VM), U3.12 (VM)
/ADER1: M5.2 (-), U3.2 (AOUT1)
/ADER2: M5.1 (+), U3.4 (AOUT2)
/AFDER1: M3.2 (-), U2.2 (AOUT1)
/AFDER2: M3.1 (+), U2.4 (AOUT2)
/AOUT1: M1.2 (-), U1.2 (AOUT1)
/AOUT2: M1.1 (+), U1.4 (AOUT2)
/BDER1: M6.1 (+), U3.7 (BOUT1)
/BDER2: M6.2 (-), U3.5 (BOUT2)
/BFDER1: M4.1 (+), U2.7 (BOUT1)
/BFDER2: M4.2 (-), U2.5 (BOUT2)
/BOUT1: M2.1 (+), U1.7 (BOUT1)
/BOUT2: M2.2 (-), U1.5 (BOUT2)
/GPIO4: J1.4, U1.9 (BIN1), U1.16 (AIN1), U2.16 (AIN1)
/GPIO12: J1.5, U1.10 (BIN2), U1.15 (AIN2), U2.15 (AIN2)
/GPIO14: J1.3, U2.9 (BIN1), U3.9 (BIN1), U3.16 (AIN1)
/GPIO15: J1.2, U2.10 (BIN2), U3.10 (BIN2), U3.15 (AIN2)
GND: C2.2, C3.2, C5.2, C6.2, C8.2, C9.2, J1.1, J3.2, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, U1.13 (GND), U1.17 (GND(PPAD)), U2.13 (GND), U2.17 (GND(PPAD)), U3.13 (GND), U3.17 (GND(PPAD))
unnamed: C1.2, U1.11 (VCP)
unnamed: C3.1, U1.14 (VINT)
unnamed: C4.2, U2.11 (VCP)
unnamed: C6.1, U2.14 (VINT)
unnamed: C7.2, U3.11 (VCP)
unnamed: C9.1, U3.14 (VINT)
unnamed: R1.1, U1.6 (BISEN)
unnamed: R2.1, U1.3 (AISEN)
unnamed: R3.1, U2.6 (BISEN)
unnamed: R4.1, U2.3 (AISEN)
unnamed: R5.1, U3.6 (BISEN)
unnamed: R6.1, U3.3 (AISEN)
VCC: J1.6, U1.1 (nSLEEP), U2.1 (nSLEEP), U3.1 (nSLEEP)

Notes on the sheet:
MOTORES LLANTAS DERECHA
MOTORES LLANTAS IZQUIERDA
MOTORES LLANTAS FRONTALES
PINES
ENTRADA DE VOLTAJE

Board: 2 copper layers, 40.0 x 70.0 mm, 26 parts (0 on the bottom side), 31 nets.

## Commit log

2019-07-02 initial kicad and .ino
2019-07-03 Schematic
2019-07-03 At schematic
2019-07-04 add file.por rover main
2019-07-05 circuit regulation
2019-07-05 Add pcb and edit sch
2019-07-08 add battery charger
2019-07-09 PCB rover v0.1
2019-07-11 Add capacitor
2019-07-15 Last Revision pcb
2019-07-18 asig SDA and SCL
2019-07-22 Last revision
2019-07-22 add footprints and manf#
2019-07-22 Accommodation revision
2019-07-22 antena wifi without cobre
2019-07-23 change V batt
2019-07-23 change diode in pcb
2019-07-23 Track revision
2019-07-24 Change tracks
2019-07-31 add program
2019-08-02 fix corners
2019-08-02 add button back and front
2019-08-02 Fix component number and etching
2019-08-02 add left and right button
2019-08-05 add bast schematic
2019-08-06 Asig. places componets
2019-08-06 RE-ROUTEO
2019-08-06 Update traces
2019-08-06 Labels
2019-08-06 ADD DIODE
2019-08-06 move V track
2019-08-07 Add SDA to jumper
2019-08-07 Update traces and placement
2019-08-07 move labels
2019-08-07 Sensors tables
2019-08-07 move edge cuts ESP32
2019-08-07 two core
2019-08-08 change jumper open in sch
2019-08-08 edit names and manf#
2019-08-08 save changes
2019-08-12 read I2C sensor with 2 cores works
2019-08-13 add bast program
2019-08-13 add function post
2019-08-13 add read CCS811
2019-08-14 fix conections CCS811
2019-08-14 rerouting CCS811
2019-08-14 clean layer
2019-08-16 activation all GPIO in direction
2019-08-20 Add reads GY-87
2019-08-20 add string all datas
2019-08-20 add serial1 send string data
2019-08-20 without while!Serial
2019-08-23 Add files via upload
    TEST page view
2019-08-23 change POST to GET
2019-08-23 string without coma
2019-08-26 html uri /data
2019-08-27 add laber to sensor data
2019-08-27 label sensor data
2019-08-28 change name rover to cat_finder
2019-08-28 change name rover_car to cat_finder_drivers
2019-08-28 change name
2019-08-28 change name in readme
2019-08-29 add licenses
2019-08-29 clone other repo
2019-08-29 description general cat finder
2019-08-29 add description
2019-09-01 change CCS811
2019-09-01 fix charger
2019-09-01 labels battery
2019-09-02 separated string data serial
2019-09-02 read data serial
2019-09-02 change string format
2019-09-02 Debug code
2019-09-03 fix memory
2019-09-03 change drill esp32
2019-09-03 add switch
2019-09-04 add touch events and implement data table
2019-09-05 change prog pines delete switch
2019-09-05 add table to uri /data
2019-09-05 add swich on/off
2019-09-05 add pin bast
2019-09-06 fix memory esp32
2019-09-06 add css in table and implement touch events
2019-09-06 add data in table
2019-09-06 add licence to readme
2019-09-09 move diode
2019-09-09 fix conection A1
2019-09-10 add diode VCC
2019-09-10 move tracks
2019-09-10 change name drivers to motors
2019-09-10 delate cache
2019-09-10 add labels
2019-09-10 change diode´s name
2019-09-12 Add MOSFET
2019-09-12 clean FCu BCu
2019-09-13 change transistor
2019-09-13 change transistor pcb
2019-09-14 cache
2019-09-17 Update diode
2019-09-25 print string in server
2019-09-27 add schematic PDF
2019-09-27 add description sketch
2019-09-27 hide data
2019-09-27 softAP with chipID
2019-09-29 Add 3d parts
2019-09-29 Add Electronics folder
2019-09-29 Add mechanics folder and 3D printing
2019-09-29 Add assets folder
2019-09-29 Add solid works files
2019-10-07 Add images
2019-10-07 update name
2019-10-07 update send data
2019-10-07 include app transform_code
2019-10-07 add asset
2019-10-07 Add simulations
2019-10-13 Fix paths
2019-10-13 remove assets of wiki
2019-10-15 best instructions
2019-10-24 fix library
2019-11-11 Best description error and add version
2019-11-11 fix HMC5883
2019-11-11 remove comments
2019-11-11 rename comments and add version
2019-11-11 Add to String TODO mag
2019-11-12 Migrate to QMC5883L
    fix error with GY-87
2019-11-12 QMC5883L new example x,y,z
2019-11-21 working in core ESP32 1.0.2
2020-02-06 Add program for Bast Pro mini to update the ESP32
2020-02-07 fix typo name
2020-02-08 update clear variable
2020-02-11 include index.html file
2020-02-11 new page controller
2020-02-11 fix script
2020-02-11 remplace comment
2020-02-12 reduce memory sendHTML
